## config/boards/shields/treadstone48/Kconfig.defconfig
```kconfig
if SHIELD_TREADSTONE48

config ZMK_KEYBOARD_NAME
    default "Treadstone48"

endif
```
